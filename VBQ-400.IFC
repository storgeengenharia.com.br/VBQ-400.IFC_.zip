Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: VBQ-400.IFC
Time: 2024-08-15T11:36:21
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Chapa Base
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Chapa Fechamento (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Chapa Lateral (3)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Chapa Meio
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Chapa Traseira
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Fechamento Suporte (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: IR 400BK ST
In: Default Storey
Material: Liga de aço (SS)

# IfcBuildingElementProxy: Perfil U Horizontal (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Perfil U Vertical (4)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Suporte Chapa
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Tampa Lateral (3)
In: Default Storey
Material: Steel
